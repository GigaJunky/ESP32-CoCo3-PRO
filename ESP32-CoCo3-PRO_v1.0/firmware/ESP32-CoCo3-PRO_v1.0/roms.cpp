// roms.cpp - run-time ROM loading from the SD card + original (copyright-free) built-in font.
#include <Arduino.h>
#include <string.h>
#include <stdlib.h>
#include "esp_heap_caps.h"
#include "SD_MMC.h"
#include "roms.h"

extern bool SD_MMC_MountOK;

uint8_t *coco3 = nullptr, *extbas11 = nullptr, *bas13 = nullptr, *disk11 = nullptr, *disk21 = nullptr;
uint8_t font_gimeChip[FONT_GIME_SIZE];
uint8_t cc2_VDG_MAP[FONT_VDG_SIZE];

// Classic 5x7 ASCII dot-matrix font (columns, bit0 = top row), ASCII 0x20..0x7E. This table is a
// long-standing public-domain design with no ties to any Tandy/Motorola ROM.
static const uint8_t k_font5x7[95][5] = {
  {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
  {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x56,0x20,0x50},{0x00,0x05,0x03,0x00,0x00},
  {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
  {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},
  {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
  {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
  {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
  {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},
  {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
  {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
  {0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
  {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00},
  {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
  {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
  {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x0C,0x52,0x52,0x52,0x3E},
  {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00},
  {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
  {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
  {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},
  {0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},
  {0x00,0x00,0x7F,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},{0x08,0x08,0x2A,0x1C,0x08}
};

// font_gimeChip: ASCII-indexed, 12 lines per glyph; glyph = rows 2..8, columns = bits 6..2.
// cc2_VDG_MAP : VDG text codes 0x00-0x7F. 0x00-0x1F = '@'..'_', 0x20-0x3F = ' '..'?', 0x40-0x7F = same, inverted.
//               glyph pixel = 0x1C (green), background 0x00 (black); codes >= 0x40 inverted = black on green.
void Roms_InitFonts(void)
{
  memset(font_gimeChip, 0, sizeof(font_gimeChip));
  for (int ch = 0x20; ch <= 0x7E; ch++)
    for (int col = 0; col < 5; col++)
    {
      const uint8_t bits = k_font5x7[ch - 0x20][col];
      for (int r = 0; r < 7; r++)
        if (bits & (1 << r)) font_gimeChip[ch * 12 + 2 + r] |= (uint8_t)(0x40 >> col);
    }
  for (int code = 0; code < 128; code++)
  {
    const int base = code & 0x3F, ascii = (base < 0x20) ? base + 0x40 : base;
    const bool inv = code >= 0x40;
    for (int r = 0; r < 12; r++)
      for (int x = 0; x < 8; x++)
      {
        const bool on = (font_gimeChip[ascii * 12 + r] & (0x80 >> x)) != 0;
        cc2_VDG_MAP[code * 96 + r * 8 + x] = (on != inv) ? 0x1C : 0x00;
      }
  }
}

static uint8_t *alloc_rom(size_t n)
{
  uint8_t *p = (uint8_t *)heap_caps_malloc(n, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
  if (!p) p = (uint8_t *)malloc(n);
  if (p) memset(p, 0xFF, n);
  return p;
}

// Reads up to `size` bytes (at least `minSize`) into dst. Looks in /ROMS first, then the card root.
static bool load_file(const char *name, uint8_t *dst, size_t size, size_t minSize)
{
  if (!dst || !SD_MMC_MountOK) return false;
  char path[48];
  for (int pass = 0; pass < 2; pass++)
  {
    snprintf(path, sizeof(path), pass == 0 ? "/ROMS/%s" : "/%s", name);
    File f = SD_MMC.open(path, FILE_READ);
    if (!f) continue;
    const size_t fsz = f.size();
    if (fsz < minSize) { Serial.printf("[ROM] %s: %u bytes, expected at least %u\n", path, (unsigned)fsz, (unsigned)minSize); f.close(); continue; }
    const size_t n = f.read(dst, size < fsz ? size : fsz);
    f.close();
    if (n >= minSize) { Serial.printf("[ROM] %s loaded (%u bytes)\n", path, (unsigned)n); return true; }
  }
  return false;
}

unsigned Roms_Load(void)
{
  unsigned missing = 0;
  coco3    = alloc_rom(ROM_COCO3_SIZE);
  extbas11 = alloc_rom(ROM_8K_SIZE);
  bas13    = alloc_rom(ROM_8K_SIZE);
  disk11   = alloc_rom(ROM_8K_SIZE);
  disk21   = alloc_rom(ROM_DISK21_SIZE);

  if (!load_file("coco3.rom", coco3, ROM_COCO3_SIZE, ROM_COCO3_SIZE))
  {
    missing |= ROMS_MISSING_COCO3;
    // Tiny stub so the CPU does not run garbage: reset vector ($FFFE) -> $8000 = "BRA *".
    if (coco3) { coco3[0] = 0x20; coco3[1] = 0xFE; coco3[ROM_COCO3_SIZE - 2] = 0x80; coco3[ROM_COCO3_SIZE - 1] = 0x00; }
    Serial.println("[ROM] coco3.rom NOT FOUND on the SD card (/ROMS/coco3.rom)");
  }
  if (!load_file("disk21.rom", disk21, ROM_DISK21_SIZE, ROM_DISK21_SIZE))
  {
    missing |= ROMS_MISSING_DISK21;
    Serial.println("[ROM] disk21.rom not found: disk controller ROM empty");
  }
  load_file("extbas11.rom", extbas11, ROM_8K_SIZE, ROM_8K_SIZE);
  load_file("bas13.rom",    bas13,    ROM_8K_SIZE, ROM_8K_SIZE);
  load_file("disk11.rom",   disk11,   ROM_8K_SIZE, ROM_8K_SIZE);

  // optional authentic-font overrides
  static uint8_t tmp[FONT_VDG_SIZE];
  if (load_file("font_gimechip.bin", tmp, FONT_GIME_SIZE, FONT_GIME_SIZE)) memcpy(font_gimeChip, tmp, FONT_GIME_SIZE);
  if (load_file("cc2_vdg_map.bin",   tmp, FONT_VDG_SIZE,  FONT_VDG_SIZE))  memcpy(cc2_VDG_MAP,   tmp, FONT_VDG_SIZE);
  return missing;
}
